# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\CONTROL;..\HARDWARE\DataScope_DP;..\HARDWARE\ENCODER;..\HARDWARE\show;..\HARDWARE\PS2;..\HARDWARE\VL53L0X\core;..\HARDWARE\VL53L0X\demo;..\HARDWARE\VL53L0X\platform;..\HARDWARE\24CXX;..\HARDWARE\IIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/show/: show.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/VL53L0X/core/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../HARDWARE/VL53L0X/demo/: vl53l0x.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_it.c
    ../HARDWARE/VL53L0X/platform/: vl53l0x_i2c.c vl53l0x_platform.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group README
    ../: README.TXT
