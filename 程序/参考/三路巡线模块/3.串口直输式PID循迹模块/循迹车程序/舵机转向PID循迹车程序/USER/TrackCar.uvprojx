# Keil uVision project TrackCar.uvprojx, settings and files
target CAR (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\Beep;..\HARDWARE\Motor;..\HARDWARE\Servo;..\HARDWARE\Common;..\HARDWARE\encoder;..\HARDWARE\Contorol;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\ADS1015;..\HARDWARE\ADS1015;..\HARDWARE\IIC;..\HARDWARE\LCD\OLED;..\HARDWARE\LCD\OLED4;..\HARDWARE\Track;..\HARDWARE\SPI;..\HARDWARE\NRF24L01;..\HARDWARE\KEY;..\HARDWARE\datastore;..\HARDWARE\STMFLASH;..\HARDWARE\PID;..\HARDWARE\Task
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Beep/: beep.c
    ../HARDWARE/Motor/: Motor.c
    ../HARDWARE/Servo/: servor.c
    ../HARDWARE/Common/: common.c
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LCD/OLED4/: OLED12864.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/Track/: track.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/datastore/: datastore.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group CONTROL
    ../HARDWARE/Contorol/: control.c
    ../HARDWARE/PID/: PID.C
    ../HARDWARE/Task/: task.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_spi.c stm32f10x_flash.c
  group README
    ../: README.TXT
