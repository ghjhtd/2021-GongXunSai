# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\MPU6050
  group Source Group 1
    ./: led.c main.c spi.c
    ./MPU6050/: mpuiic.c mpu6050.c parameter.c
